# Keil uVision project CH563.uvproj, settings and files
target CH563 (ARM-ADS)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: CH563 +hex
  c flags: Optim=1 wLevel=1
  c include: ..\User;..\PUB;..\SRC
  library: MicroLIB
  scatter file: ..\SRC\CH563D64.SCF
  group user
    ../User/: CH563.C main.c PLC.c ISPXT563.O
    ../PUB/: CH563NET.lib
  group sys
    ../SRC/: STARTUP.S SYSFREQ.C
